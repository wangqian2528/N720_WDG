# IAR project N720_WDG.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\source; ..\STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: N720_WDG.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ../source/: main.c sys.c
  group LIB
    ../STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_exti.c stm8s_gpio.c stm8s_iwdg.c stm8s_tim4.c stm8s_uart1.c
